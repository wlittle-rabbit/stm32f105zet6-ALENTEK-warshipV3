# IAR project FS_AI_C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\CMSIS\CM3\CoreSupport; Libraries\STM32F10x_StdPeriph_Driver\inc; User\INC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FS_AI_C.hex
  ILINK.IlinkOutputFile: FS_AI_C.out
  ILINK.IlinkIcfFile: E:\嵌入式单片机学习\我的练习\V3开发板练习\io-uart-timer-adc-spi_redcon-oled\EVARM\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EVARM
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    User/: beep.c inputcapture.c lcd.c lcd_fmsc.c main.c oled.c redcontrol.c time_user.c uart.c w25.c
  group User/include
    User/: xiaohuabao.h
